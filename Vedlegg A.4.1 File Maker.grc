options:
  parameters:
    author: mathias
    generate_options: qt_gui
    id: option
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: button
  id: variable_qtgui_push_button
  parameters:
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: cut_off
  id: variable_qtgui_range
  parameters:
    label: Cut-Off MHz
    orient: Qt.Horizontal
    start: '1'
    step: '0.5'
    stop: '100'
    value: '5'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate MHz
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '250'
    value: '250'
  states: {}
- name: tra_wit
  id: variable_qtgui_range
  parameters:
    label: Tran-With MHz
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '100'
    value: '1'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_UNIFORM
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/mathias/workarea/gnuradio/gr-program/Testing 03.05.22/SampleRate100MSS^-1/10MHz1.dat
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: button
    input_index: '0'
    num_inputs: '1'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_off*1E6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate*1E6
    type: fir_filter_ccf
    width: tra_wit*1E6
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*1E6
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_selector_1, '0']
- [blocks_selector_1, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
