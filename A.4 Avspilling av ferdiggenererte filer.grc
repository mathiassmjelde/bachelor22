options:
  parameters:
    author: mathias
    generate_options: qt_gui
    id: streamfrafil1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    label: Amplitude [Normal]
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10'
    value: '3'
  states: {}
- name: cut_off
  id: variable_qtgui_range
  parameters:
    label: Cut-Off MHz
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '200'
    value: '5'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate MHz
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '200'
    value: '20'
  states: {}
- name: senter_freq
  id: variable_qtgui_range
  parameters:
    label: Frekvens [MHz]
    orient: Qt.Horizontal
    start: '100'
    step: '100'
    stop: '6000'
    value: '100'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/mathias/workarea/gnuradio/gr-program/Testing 03.05.22/SampleRate20MSS^-1/6MHz.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp/10
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate*1e6
    fc: senter_freq*1e6
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: senter_freq*1E6
    dev_addr: addr=192.168.10.2
    dev_args: master_clock_rate=200e6
    gain0: amp/10
    norm_gain0: 'True'
    samp_rate: samp_rate*1e6
    stream_chans: '[0]'
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
